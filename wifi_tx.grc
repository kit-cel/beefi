options:
  parameters:
    generate_options: qt_gui
    id: wifi_tx
    output_language: python
    realtime_scheduling: '1'
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: duty_cycle
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,8
    label: Duty Cycle
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '5'
  states: {}
- name: period
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,8
    label: Period
    orient: Qt.Horizontal
    rangeType: int
    start: '2'
    step: '1'
    stop: '1000'
    value: '100'
  states: {}
- name: pre_amp_gain
  id: variable
  parameters:
    value: '-40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: usrp_gain
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,2,2
    label: Output Power
    label0: 0dB
    label1: 45dB
    label2: 90dB
    num_opts: '3'
    option1: '45'
    option2: '90'
    type: int
    value: '0'
  states: {}
- name: beefi_packet_gen_0
  id: beefi_packet_gen
  parameters:
    directory: /home/beefi/sdr/GrData/indexed
  states: {}
- name: beefi_packet_gen_0_0
  id: beefi_packet_gen
  parameters:
    directory: /home/beefi/sdr/GrData/indexed
  states: {}
- name: beefi_param_logger_0
  id: beefi_param_logger
  parameters:
    channels: '2'
    dir: /var/log/beefi
    duty_cycle: duty_cycle
    log_period: '10'
    output_power: usrp_gain - 90
    period: period
  states: {}
- name: beefi_pwm_source_0
  id: beefi_pwm_source
  parameters:
    duty: duty_cycle / 100.0
    maxoutbuf: '4096'
    minoutbuf: '4096'
    period: period
  states: {}
- name: beefi_pwm_source_0_0
  id: beefi_pwm_source
  parameters:
    duty: duty_cycle / 100
    maxoutbuf: '4096'
    minoutbuf: '4096'
    period: period
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(pre_amp_gain / 20)
    maxoutbuf: '8192'
    minoutbuf: '8192'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(pre_amp_gain / 20)
    maxoutbuf: '8192'
    minoutbuf: '8192'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 10,0,4,10
    name: Control Signal
    size: '512'
    srate: '1'
    tr_level: '.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ylabel: Signal ID
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: bandwidth
    center_freq0: 5.8e9
    dev_addr: '"serial=311B3ED"'
    dev_args: '""'
    gain0: usrp_gain
    len_tag_name: ''
    norm_gain0: 'False'
    otw: sc12
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: bandwidth
    center_freq0: 2.45e9
    dev_addr: '"serial=30ECB69"'
    dev_args: '""'
    gain0: usrp_gain
    len_tag_name: ''
    norm_gain0: 'False'
    otw: sc12
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [beefi_packet_gen_0, '0', blocks_multiply_const_vxx_0, '0']
- [beefi_packet_gen_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [beefi_pwm_source_0, '0', beefi_packet_gen_0, '0']
- [beefi_pwm_source_0, '0', blocks_char_to_float_0, '0']
- [beefi_pwm_source_0_0, '0', beefi_packet_gen_0_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', beefi_param_logger_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', beefi_param_logger_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', uhd_usrp_sink_0_0, '0']

metadata:
  file_format: 1
